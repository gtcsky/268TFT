# Keil uVision project BG268 TFT.uvprojx, settings and files
target BG268_TFT (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: BG268_TFT
  AfterMake: fromelf.exe --bin  -o  ./bin  ./Objects/@L.axf
  AfterMake: fromelf.exe .\Objects\@L.axf --i32combined --output .\bin\@L.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OTA_MODE=SINGLE_BANK_NOFCT, CFG_CP,    CFG_QFN48,    CFG_SLEEP_MODE=PWR_MODE_SLEEP,    DEBUG_INFO = 1,    HAL_KEY=TRUE,
  c misc: -DADV_NCONN_CFG=0x01   -DADV_CONN_CFG=0x02   -DSCAN_CFG=0x04    -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02   -DPERIPHERAL_CFG=0x04   -DCENTRAL_CFG=0x08   -DHOST_CONFIG=0x4
  c include: .\Source;..\components\ble\include;..\components\inc;..\components\ble\controller\include;..\components\ble\hci;..\components\osal\include;..\components\inc;..\components\common;..\components\ble\host;..\components\profiles\Roles;..\components\profiles\GATT;..\components\profiles\DevInfo;..\components\profiles\Batt;..\components\profiles\HID;..\components\profiles\ota_app;..\components\driver\common;..\components\driver\log;..\components\driver\gpio;..\components\driver\uart;..\components\driver\i2c;..\components\driver\adc;..\components\driver\clock;..\components\driver\pwm;..\components\driver\pwrmgr;..\components\driver\kscan;..\components\driver\spi;..\components\driver\flash;..\components\driver\watchdog;..\components\driver\timer;..\components\libraries\datetime;..\lib;.\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\misc\rom1Sym.txt --keep=jump_table_base  --keep=global_config
  group app
    ./user/src/: bleSmartPeripheral_Main.c OSAL_bleSmartPeripheral.c bleSmartPeripheral.c systems_parameters.c battery.c command_center.c display.c light.c temp.c user_error.c user_lightEffect.c user_color.c user_watchdog.c user_flash.c user_test.c user_utils.c user_remainTimer.c
  group protocol
    ./user/src/: protocol_uart.c
  group driver
    ../components/driver/clock/: clock.c
    ../components/driver/pwrmgr/: pwrmgr.c
    ../components/driver/common/: common.c
    ../components/driver/gpio/: gpio.c
    ../components/driver/uart/: uart.c
    ../components/driver/log/: my_printf.c
    ../components/driver/adc/: adc.c
    ../components/driver/pwm/: pwm.c
    ../components/driver/flash/: flash.c
    ../components/driver/spi/: spi.c
    ./user/src/: keys.c
    ../components/driver/watchdog/: watchdog.c
  group profile
    ../components/profiles/Batt/: battservice.c
    ../components/profiles/DevInfo/: devinfoservice.c
    ../components/profiles/Roles/: gapgattserver.c peripheral.c gap.c gapbondmgr.c
    ../components/profiles/GATT/: gattservapp.c
    ../components/profiles/ota_app/: ota_app_service.c
    ./user/src/: simpleGATTprofile.c LumeControlprofile.c LumeCubeprofile.c
  group arch
    ./user/src/: main.c
  group osal
    ../components/osal/snv/: osal_snv.c
  group jump
    ../misc/: jump_table.c
  group rf
    ../lib/: rf.lib
  group tools
    ./: scatter_load.sct
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
